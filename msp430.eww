<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project1\MSP430G2253.ewp</path>
    </project>
    <batchBuild />
</workspace>
